v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {LELO_SVOD_SKY130A/RO.sym} 30 -40 0 0 {name=x1}
C {devices/lab_pin.sym} 180 -60 0 1 {name=p4 sig_type=std_logic lab=VO}
C {devices/ipin.sym} -120 -60 0 0 {name=p5 lab=VDD}
C {devices/ipin.sym} -120 -40 0 0 {name=p1 lab=VC}
C {devices/ipin.sym} -120 -20 0 0 {name=p2 lab=VSS}
