v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sky130_fd_pr/res_iso_pw.sym} 0 0 0 0 {name=R1
W=2.65
L=2.65
model=res_iso_pw
spiceprefix=X
mult=1}
C {devices/ipin.sym} 0 -30 0 0 {name=p1 lab=p1}
C {devices/ipin.sym} 0 30 0 0 {name=p2 lab=p2}
